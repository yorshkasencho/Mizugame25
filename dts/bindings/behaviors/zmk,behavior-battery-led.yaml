## dts/bindings/behaviors/zmk,behavior-battery-led.yaml
```yaml
# SPDX-License-Identifier: MIT

description: Battery LED Behavior
compatible: "zmk,behavior-battery-led"
include: one_param.yaml
```
